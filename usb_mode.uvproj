# Keil uVision project usb_mode.uvproj, settings and files
target Target 1 (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: T5L51 +hex
  AfterMake: .\obj\1.bat
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group CH376
    ./: STARTUP_M5.A51 main.c
    ./app/app_usb/: app_interface.c file_sys.c
    ./driver/dgus/: dgus.c
    ./driver/system/: sys.c
    ./driver/uart/: uart.c
    ./driver/usb/: para_port.c
    ./app/app_dgus/: usb_dgus.c
