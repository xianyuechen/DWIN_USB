# Keil uVision project lib_make_dgus_api.uvproj, settings and files
target lib_projects (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: dgus_api +hex (library)
  AfterMake: .\lib\dwin.bat
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group dgus_api
    ./src/: dgus.c
  group main_test
    ./src/: main.c
