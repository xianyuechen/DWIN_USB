# Keil uVision project lib_make_all.uvproj, settings and files
target lib_projects (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: dwin +hex (library)
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group dgus_api
    ../dgus_api/src/: dgus.c
  group dwin_51
    ../dwin_51/src/: sys.c
  group uart
    ../uart/src/: uart.c
  group usb
    ../usb/src/: app_interface.c file_sys.c para_port.c usb_dgus.c
  group main_test
    ./src/: main.c
