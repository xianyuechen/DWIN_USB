# Keil uVision project usb_mode.uvproj, settings and files
target components (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: T5L51 +hex
  AfterMake: .\obj\1.bat
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group dgus_api
    ../../components/dgus_api/: dgus.c
  group system
    ../../components/system/: sys.c STARTUP_M5.A51
  group uart
    ../../components/uart/: uart.c
  group usb
    ../../components/usb/: app_interface.c file_sys.c usb_dgus.c para_port.c
  group main
    ./main/: main.c
