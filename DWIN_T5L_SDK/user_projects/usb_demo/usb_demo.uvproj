# Keil uVision project usb_demo.uvproj, settings and files
target projects (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: T5L51 +hex
  AfterMake: .\obj\1.bat
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group usb_demo
    ./main/: main.c dgus_config.c
  group lib
    ../../lib/: dgus_api.lib dwin_51.lib uart.lib usb.lib
