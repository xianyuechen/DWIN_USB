# Keil uVision project lib_make_all.uvproj, settings and files
target components (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: DWIN +hex (library)
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group dgus_api
    ../../components/dgus_api/: dgus.c
  group dwin_51
    ../../components/dwin_51/: sys.c
  group uart
    ../../components/uart/: uart.c
  group usb
    ../../components/usb/: app_interface.c file_sys.c para_port.c usb_dgus.c
