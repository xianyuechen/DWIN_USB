# Keil uVision project lib_make_usb.uvproj, settings and files
target components (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: usb +hex (library)
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group usb
    ../../components/usb/: app_interface.c file_sys.c para_port.c usb_dgus.c
