# Keil uVision project lib_make_dwin_51.uvproj, settings and files
target components (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: dwin_51 +hex (library)
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group dwin_51
    ../../components/dwin_51/: sys.c
