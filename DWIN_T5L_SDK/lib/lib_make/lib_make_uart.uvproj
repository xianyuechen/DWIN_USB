# Keil uVision project lib_make_uart.uvproj, settings and files
target components (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: uart +hex (library)
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group uart
    ../../components/uart/: uart.c
