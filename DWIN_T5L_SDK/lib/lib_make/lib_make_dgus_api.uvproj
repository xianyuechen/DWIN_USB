# Keil uVision project lib_make_dgus_api.uvproj, settings and files
target components (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: dgus_api +hex (library)
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group dgus_api
    ../../components/dgus_api/: dgus.c
